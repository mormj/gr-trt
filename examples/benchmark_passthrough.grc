options:
  parameters:
    generate_options: no_gui
    id: benchmark_passthrough
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: actual_samples
  id: variable
  parameters:
    value: (fft_size * batch_size) * int (nsamples / (fft_size * batch_size))
  states: {}
- name: batch_size
  id: variable
  parameters:
    value: '131072'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000'
    value: '50'
  states: {state: disabled}
- name: nsamples
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(nsamples / batch_size)
    type: complex
    vlen: batch_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: batch_size
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
    vlen: batch_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[x+1j*(255-x) for x in list(range(256))]'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '32000'
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.endt = time.time()

      meas_tput = self.actual_samples / (self.endt-self.startt)
      print( "{} MSamps / sec, {}, {}".format(meas_tput/1e6, self.nsamples, self.endt-self.startt ))

      #d = self.vs1.data()
      #print(d[0:100])
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      print("starting ...")
      self.startt = time.time()
    section: main_after_init
  states: {}
- name: trt_passthrough_0
  id: trt_passthrough
  parameters:
    batch_size: batch_size
    mem_model: '0'
  states: {}
- name: vs1
  id: blocks_vector_sink_x
  parameters:
    type: complex
    vlen: '1024'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', trt_passthrough_0, '0']
- [blocks_null_source_0, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_head_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [trt_passthrough_0, '0', blocks_null_sink_0, '0']
- [trt_passthrough_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
