options:
  parameters:
    generate_options: no_gui
    id: benchmark_fft
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: actual_samples
  id: variable
  parameters:
    value: (fft_size * batch_size) * int (nsamples / (fft_size * batch_size))
  states: {}
- name: batch_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: nsamples
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(nsamples / fft_size)
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[x+1j*(255-x) for x in list(range(256))]'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.endt = time.time()

      meas_tput = self.actual_samples / (self.endt-self.startt)
      print( "{} MSamps / sec, {}, {}".format(meas_tput/1e6, self.nsamples, self.endt-self.startt ))

      #d = self.vs1.data()
      #print(d[0:100])
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      print("starting ...")
      self.startt = time.time()
    section: main_after_init
  states: {}
- name: trt_fft_0
  id: trt_fft
  parameters:
    batch_size: batch_size
    fft_size: fft_size
    forward: 'True'
    memory_model: trt.memory_model_t.TRADITIONAL
    shift: 'False'
    window: window.blackmanharris(1024)
  states: {}
- name: trt_fft_0_0
  id: trt_fft
  parameters:
    batch_size: batch_size
    fft_size: fft_size
    forward: 'False'
    memory_model: trt.memory_model_t.TRADITIONAL
    shift: 'False'
    window: window.blackmanharris(1024)
  states: {state: bypassed}
- name: trt_fft_0_1
  id: trt_fft
  parameters:
    batch_size: batch_size
    fft_size: fft_size
    forward: 'False'
    memory_model: trt.memory_model_t.TRADITIONAL
    shift: 'False'
    window: window.blackmanharris(1024)
  states: {state: bypassed}
- name: trt_fft_0_2
  id: trt_fft
  parameters:
    batch_size: batch_size
    fft_size: fft_size
    forward: 'True'
    memory_model: trt.memory_model_t.TRADITIONAL
    shift: 'False'
    window: window.blackmanharris(1024)
  states: {state: bypassed}
- name: vs1
  id: blocks_vector_sink_x
  parameters:
    type: complex
    vlen: '1024'
  states: {state: disabled}

connections:
- [blocks_head_0, '0', trt_fft_0, '0']
- [blocks_null_source_0, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_head_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [trt_fft_0, '0', trt_fft_0_0, '0']
- [trt_fft_0_0, '0', trt_fft_0_1, '0']
- [trt_fft_0_1, '0', trt_fft_0_2, '0']
- [trt_fft_0_2, '0', blocks_null_sink_0, '0']
- [trt_fft_0_2, '0', vs1, '0']

metadata:
  file_format: 1
