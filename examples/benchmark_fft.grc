options:
  parameters:
    generate_options: no_gui
    id: benchmark_fft
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: nsamples
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: nsamples
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.endt = time.time()

      meas_tput = self.nsamples / (self.endt-self.startt)
      print( "{} MSamps / sec".format(meas_tput/1e6) )
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}
- name: trt_fft_0
  id: trt_fft
  parameters:
    batch_size: '1024'
    fft_size: '1024'
    forward: 'True'
    shift: 'False'
    window: window.blackmanharris(1024)
  states: {}

connections:
- [blocks_head_0, '0', trt_fft_0, '0']
- [blocks_null_source_0, '0', blocks_head_0, '0']
- [trt_fft_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
