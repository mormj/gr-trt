options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: classifier_fcn
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6 / 1000
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: output_len
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/benchmark-dnn/RML2016.10a.test.fc32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/benchmark-dnn/RML2016.10a.test.lbl
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/benchmark-dnn/RML2016.10a.test.fc32
    repeat: 'False'
    type: float
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    blocksize: '128'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: output_len
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalize',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              self.vlen = vlen
              self.set_output_multiple(vlen)
              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              
              nvec = int(len(output_items[0]) / self.vlen)
              
              for i in range(nvec):
                  m = max(input_items[0][i*self.vlen:(i+1)*self.vlen])
                  ii = input_items[0][i*self.vlen:(i+1)*self.vlen]
                  output_items[0][i*self.vlen:(i+1)*self.vlen] = ii / m
              
              return len(output_items[0])
    vlen: '256'
  states: {state: bypassed}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: output_len
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '100'
    srate: '1'
    type: float
  states: {state: disabled}
- name: trt_confusion_matrix_0
  id: trt_confusion_matrix
  parameters:
    class_labels: '[''8PSK'', ''AM-DSB'', ''AM-SSB'', ''BPSK'', ''CPFSK'', ''GFSK'', ''PAM4'', ''QAM16'', ''QAM64'', ''QPSK'', ''WBFM'']'
  states: {}
- name: trt_infer_0
  id: trt_infer
  parameters:
    batch_size: '1'
    onnx_pathname: /share/gnuradio/benchmark-dnn/VTCNN2.onnx
    type: float
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '0', trt_confusion_matrix_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_file_source_0, '0', blocks_complex_to_float_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_0, '0', trt_confusion_matrix_0, '1']
- [blocks_file_source_0_1, '0', epy_block_0, '0']
- [blocks_file_source_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleave_0, '0', epy_block_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_argmax_xx_0, '0']
- [epy_block_0, '0', trt_infer_0, '0']
- [trt_infer_0, '0', blocks_stream_to_vector_0, '0']
- [trt_infer_0, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
