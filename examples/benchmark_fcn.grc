options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: benchmark_fcn
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '"/share/gnuradio/benchmark-dnn/RML2016.10a_forFCN.test.fc32"'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6 / 1000
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'False'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      num_samples = os.stat(self.filename).st_size / 4

      self.endt = time.time()

      meas_tput = num_samples / (self.endt-self.startt)
      print( "{} MSamps / sec".format(meas_tput/1e6) )
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}
- name: trt_infer_0
  id: trt_infer
  parameters:
    batch_size: batch_size
    onnx_pathname: /share/gnuradio/benchmark-dnn/FCN.onnx
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', trt_infer_0, '0']
- [trt_infer_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
