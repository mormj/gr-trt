options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: benchmark_fcn
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '"/share/gnuradio/benchmark-dnn/tmp.fc32"'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6 / 1000
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1000000'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: list(range(256)) * int(num_samples / 256)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      #num_samples = os.stat(self.filename).st_size / 4
      #print(num_samples)
      num_samples = self.num_samples

      self.endt = time.time()

      meas_tput = num_samples / (self.endt-self.startt)
      print( "{} MSamps / sec".format(meas_tput/1e6) )
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}
- name: trt_infer_0
  id: trt_infer
  parameters:
    dla_core: '-1'
    memory_model: trt.memory_model_t.PINNED
    onnx_pathname: /share/gnuradio/benchmark-dnn/FCNSMALL_1.onnx
    type: float
    workspace_size: '1073741824'
  states: {}

connections:
- [blocks_file_source_0, '0', trt_infer_0, '0']
- [blocks_head_0, '0', trt_infer_0, '0']
- [blocks_null_source_0, '0', blocks_head_0, '0']
- [blocks_vector_source_x_0, '0', trt_infer_0, '0']
- [trt_infer_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
