options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: classifier_fcn
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6 / 100
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: output_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/gr39/src/gr-trt/data/RML2016.10a_forFCN.test.fc32
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/gr39/src/gr-trt/data/RML2016.10a_forFCN.test.lbl
    repeat: 'False'
    type: short
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: output_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: output_len
    nrows: '256'
    samp_rate: samp_rate
    type: float
    update_time: '0.02'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Inferred
    label2: Actual
    nconnections: '2'
    size: '5000'
    srate: '1'
    type: float
  states: {}
- name: trt_confusion_matrix_0
  id: trt_confusion_matrix
  parameters:
    class_labels: '[''8PSK'', ''AM-DSB'', ''AM-SSB'', ''BPSK'', ''CPFSK'', ''GFSK'', ''PAM4'', ''QAM16'', ''QAM64'', ''QPSK'', ''WBFM'']'
  states: {}
- name: trt_infer_0
  id: trt_infer
  parameters:
    dla_core: '-1'
    memory_model: trt.memory_model_t.TRADITIONAL
    onnx_pathname: /share/gnuradio/gr39/src/gr-trt/data/FCNSMALL_32.onnx
    type: float
    workspace_size: '1073741824'
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '0', trt_confusion_matrix_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_0, '0', trt_confusion_matrix_0, '1']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_argmax_xx_0, '0']
- [blocks_throttle_0, '0', trt_infer_0, '0']
- [trt_infer_0, '0', blocks_stream_to_vector_0, '0']
- [trt_infer_0, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
