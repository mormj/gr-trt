options:
  parameters:
    generate_options: no_gui
    id: benchmark_fft
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: nsamples
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(nsamples / fft_size)
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
    vlen: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.endt = time.time()

      meas_tput = self.nsamples / (self.endt-self.startt)
      print( "{} MSamps / sec".format(meas_tput/1e6) )
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}

connections:
- [blocks_head_0, '0', fft_vxx_0, '0']
- [blocks_null_source_0, '0', blocks_head_0, '0']
- [fft_vxx_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', fft_vxx_0_2, '0']
- [fft_vxx_0_1, '0', blocks_null_sink_0, '0']
- [fft_vxx_0_2, '0', fft_vxx_0_1, '0']

metadata:
  file_format: 1
